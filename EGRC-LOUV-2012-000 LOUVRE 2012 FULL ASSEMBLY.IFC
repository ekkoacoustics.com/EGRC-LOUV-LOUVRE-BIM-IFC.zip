Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Louvre\EGRC-LOUV-2012-000 LOUVRE 2012 FULL ASSEMBLY.IFC
Time: 2025-01-02T14:55:53+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 49.1084436474979356; Volume Measure: 0.0491084436474979; Area Measure: 9.4117891106274953

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 49.1084436474979356; Volume Measure: 0.0491084436474979; Area Measure: 9.4117891106274953

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 49.1084436474979356; Volume Measure: 0.0491084436474979; Area Measure: 9.4117891106274953

# IfcBuildingElementProxy (142)
In: default BuildingStorey
Name
EGRC-LOUV-2012-000 LOUVRE 2012 FULL ASSEMBLY | PSet_Mass_Property - Mass Measure: 49.1084436474979356; Volume Measure: 0.0491084436474979; Area Measure: 9.4117891106274953
H Section Hanging Extrusion + F000264 P50 Suspension Fitting
20 x H Section Hanging Extrusion - 100mm
20 x F000264 P50 SUSPENSION FITTING.SLDPRT
20 x F000264 P50 Clutch Fitting
20 x F000264 P50 Tensile Steel Wire 2m
20 x F000264 P50 M5 Threaded Bolt
20 x F000264 P50 Top Threaded Insert
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-1
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-2
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-3
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-4
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-5
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-6
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-7
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-8
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-9
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-10
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-11
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-12
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-13
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-14
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-15
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-16
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-17
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-18
EGRC-LOUV-2012-000 LOUVRE 2012
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-19
