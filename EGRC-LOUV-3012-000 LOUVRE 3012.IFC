Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Louvre\EGRC-LOUV-3012-000 LOUVRE 3012.IFC
Time: 2025-01-02T14:54:04+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 58.6007999999995945; Volume Measure: 0.0586007999999996; Area Measure: 10.7470206752981774

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 58.6007999999995945; Volume Measure: 0.0586007999999996; Area Measure: 10.7470206752981774

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 58.6007999999995945; Volume Measure: 0.0586007999999996; Area Measure: 10.7470206752981774

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGRC-LOUV-3012-000 LOUVRE 3012 | PSet_Mass_Property - Mass Measure: 58.6007999999995945; Volume Measure: 0.0586007999999996; Area Measure: 10.7470206752981774
EGRC-LOUV-3012-000 LOUVRE 3012
