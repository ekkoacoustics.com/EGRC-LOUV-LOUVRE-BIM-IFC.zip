Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Louvre\EGRC-LOUV-2012-000 LOUVRE 2012.IFC
Time: 2025-01-02T14:52:59+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 48.7327680000000285; Volume Measure: 0.0487327680000000; Area Measure: 9.0040446752981751

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 48.7327680000000285; Volume Measure: 0.0487327680000000; Area Measure: 9.0040446752981751

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 48.7327680000000285; Volume Measure: 0.0487327680000000; Area Measure: 9.0040446752981751

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGRC-LOUV-2012-000 LOUVRE 2012 | PSet_Mass_Property - Mass Measure: 48.7327680000000285; Volume Measure: 0.0487327680000000; Area Measure: 9.0040446752981751
EGRC-LOUV-2012-000 LOUVRE 2012
